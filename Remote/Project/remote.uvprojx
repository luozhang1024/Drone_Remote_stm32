# Keil uVision project remote.uvprojx, settings and files
target remote (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: remote
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\FreeRTOS\include;..\FreeRTOS\port\MemMang;..\FreeRTOS\port\RVDS\ARM_CM3;..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\User\BSP\adc;..\User\App;..\User\BSP\iic;..\User\BSP\key;..\User\BSP\led;..\User\BSP\nrf24l01;..\User\BSP\oled;..\User\BSP\spi;..\User\BSP\tim;..\User\BSP\usart1;..\User\BSP\usart3;..\User\System;..\User\RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/System/: main.c nvic.c stm32f10x_it.c systick.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group App
    ../User/App/: filter.c imath.c pair_freq.c sendpacket.c
  group BSP
    ../User/BSP/adc/: adc.c
    ../User/BSP/iic/: iic.c
    ../User/BSP/key/: key.c
    ../User/BSP/led/: led.c
    ../User/BSP/nrf24l01/: nrf24l01.c
    ../User/BSP/oled/: oled.c OledFont.c
    ../User/BSP/spi/: spi.c
    ../User/BSP/tim/: timing_trigger.c
    ../User/BSP/usart1/: usart1.c
    ../User/BSP/usart3/: usart3.c
  group RTOS App
    ../User/RTOS/: app_rtos.c app_tasks.c app_hooks.c
